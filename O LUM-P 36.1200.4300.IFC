Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: O LUM-P 36.1200.4300.IFC
Time: 2023-12-08T10:51:22
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: O LUM-P 36.1200.4300
In: Default Storey
SolidWorks Custom Properties - Description: O LUM-P 36.1200.4300
PSet_Mass_Property - Mass Measure: 273172139; Area Measure: 0.735446 m2; Volume Measure: 0.00359575 m3
