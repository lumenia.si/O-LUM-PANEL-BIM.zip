Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: O LUM-P 36.600.3960.IFC
Time: 2023-12-08T10:50:16
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: O LUM-P 36.600.3960
In: Default Storey
SolidWorks Custom Properties - Description: O LUM-P 36.600.3960
PSet_Mass_Property - Mass Measure: 3.61105; Area Measure: 0.732326 m2; Volume Measure: 0
